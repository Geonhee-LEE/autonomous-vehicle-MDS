Commit message: acml parma changed

File: robot_description/urdf/platform_base_allink.urdf (robot description, URDF)
Before this commit: robot platform_base_allink, 7 links, 6 joints
Joints:
- joint IMU_joint: origin xyz=-0.195 0 0.695 rpy=-1.5708 0 -1.5708 -> xyz=-0.195 0 0.695 rpy=0 3.14 0
